# Keil uVision project stm32wb55_nucleo68_board.uvprojx, settings and files
target stm32wb55_nucleo68_board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: stm32wb55_nucleo68_board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32WB55xx,USE_HAL_DRIVER,CORE_CM4,__ASSERT_MSG,USE_FULL_ASSERT
  c include: ..\config;..\..\..\framework\base\inc;..\..\..\middleware\external\FreeRTOS-Kernel\CMSIS_RTOS_V2;..\..\..\middleware\external\FreeRTOS-Kernel\include;..\..\..\middleware\external\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;..\..\..\middleware\internal\clock_manager\inc;..\..\..\middleware\internal\clock_manager\port\STM32WBxx;..\..\..\middleware\internal\debug_module\inc;..\..\..\middleware\internal\debug_module\port\STM32WBxx;..\..\..\driver\STM32WBxx\CMSIS\core\include;..\..\..\driver\STM32WBxx\CMSIS\device\include;..\..\..\driver\STM32WBxx\hal\inc;..\..\..\driver\STM32WBxx\machine\inc;..\..\..\utils\ring_buff\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\..\..\driver\STM32WBxx\CMSIS\device\src\arm\linker\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W,L6330W
  group framework\base
    ../../../framework/base/src/: init.c object.c service.c message.c
  group middleware\external\FreeRTOS-Kernel
    ../../../middleware/external/FreeRTOS-Kernel/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../middleware/external/FreeRTOS-Kernel/hooks/: hooks.c
    ../../../middleware/external/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../../../middleware/external/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
    ../../../middleware/external/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group middleware\internal\clock_manager
    ../../../middleware/internal/clock_manager/src/: clock_manager.c
    ../../../middleware/internal/clock_manager/port/STM32WBxx/: stm32wbxx_clock.c
  group middleware\internal\debug_module
    ../../../middleware/internal/debug_module/src/: dbg_trace.c dbg_assert.c
    ../../../middleware/internal/debug_module/port/STM32WBxx/: stm32wbxx_uart.c
  group driver\startup
    ../../../driver/STM32WBxx/CMSIS/device/src/arm/: startup_stm32wb55xx_cm4.s
    ../../../driver/STM32WBxx/CMSIS/device/src/: system_stm32wbxx.c
  group driver\STM32WBxx\hal
    ../../../driver/STM32WBxx/hal/src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_comp.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_irda.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_lcd.c stm32wbxx_hal_lptim.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pka.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_qspi.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_sai.c stm32wbxx_hal_sai_ex.c stm32wbxx_hal_smartcard.c stm32wbxx_hal_smartcard_ex.c stm32wbxx_hal_smbus.c stm32wbxx_hal_smbus_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_tsc.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_usart.c stm32wbxx_hal_usart_ex.c stm32wbxx_hal_wwdg.c
  group driver\STM32WBxx\machine
    ../../../driver/STM32WBxx/machine/nucleo68_board/: hardware_if.c
