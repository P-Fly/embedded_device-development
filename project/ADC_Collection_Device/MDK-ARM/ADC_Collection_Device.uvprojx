# Keil uVision project ADC_Collection_Device.uvprojx, settings and files
target ADC_Collection_Device (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ADC_Collection_Device +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32WB55xx,USE_HAL_DRIVER,CORE_CM4,__ASSERT_MSG,USE_FULL_ASSERT
  c include: ..\config;..\..\..\utils\inc;..\..\..\driver\STM32WBxx\CMSIS\core\include;..\..\..\driver\STM32WBxx\CMSIS\device\include;..\..\..\driver\STM32WBxx\hal\inc;..\..\..\driver\STM32WBxx\machine\inc;..\..\..\middleware\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\..\middleware\FreeRTOS\Source\include;..\..\..\middleware\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\middleware\debug_module\inc;..\..\..\middleware\debug_module\port\STM32WBxx;..\..\..\middleware\led_manager\inc;..\..\..\middleware\led_manager\port\STM32WBxx;..\..\..\middleware\button_manager\inc;..\..\..\middleware\button_manager\port\STM32WBxx;..\..\..\middleware\adc_manager\inc;..\..\..\middleware\adc_manager\port\STM32WBxx;..\..\..\framework\base\inc;..\..\..\framework\services\battery_service\inc;..\..\..\framework\services\ble_service\inc;..\..\..\framework\services\button_service\inc;..\..\..\framework\services\data_service\inc;..\..\..\framework\services\display_service\inc;..\..\..\framework\services\led_service\inc;..\application\ui_service\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\..\..\driver\STM32WBxx\CMSIS\device\src\arm\linker\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W,L6330W
  group driver\startup
    ../../../driver/STM32WBxx/CMSIS/device/src/arm/: startup_stm32wb55xx_cm4.s
    ../../../driver/STM32WBxx/CMSIS/device/src/: system_stm32wbxx.c
  group driver\STM32WBxx\hal
    ../../../driver/STM32WBxx/hal/src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_comp.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_irda.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_lcd.c stm32wbxx_hal_lptim.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pka.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_qspi.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_sai.c stm32wbxx_hal_sai_ex.c stm32wbxx_hal_smartcard.c stm32wbxx_hal_smartcard_ex.c stm32wbxx_hal_smbus.c stm32wbxx_hal_smbus_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_tsc.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_usart.c stm32wbxx_hal_usart_ex.c stm32wbxx_hal_wwdg.c
  group driver\STM32WBxx\machine
    ../../../driver/STM32WBxx/machine/src/: hardware_if.c
  group middleware\FreeRTOS
    ../../../middleware/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../middleware/FreeRTOS/Source/: tasks.c queue.c timers.c list.c event_groups.c stream_buffer.c
    ../../../middleware/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../middleware/FreeRTOS/Source/hooks/: hooks.c
  group middleware\debug_module
    ../../../middleware/debug_module/src/: dbg_trace.c dbg_assert.c
    ../../../middleware/debug_module/port/STM32WBxx/: stm32wbxx_uart.c
  group middleware\led_manager
    ../../../middleware/led_manager/src/: led_manager.c
    ../../../middleware/led_manager/port/STM32WBxx/: stm32wbxx_led.c
  group middleware\button_manager
    ../../../middleware/button_manager/src/: button_manager.c
    ../../../middleware/button_manager/port/STM32WBxx/: stm32wbxx_button.c
  group middleware\adc_manager
    ../../../middleware/adc_manager/src/: adc_manager.c
    ../../../middleware/adc_manager/port/STM32WBxx/: stm32wbxx_adc.c
  group framework\base
    ../../../framework/base/src/: init.c object.c service.c
  group services\led_service
    ../../../framework/services/led_service/src/: led_service.c
  group services\button_service
    ../../../framework/services/button_service/src/: button_service.c
  group services\display_service
    ../../../framework/services/display_service/src/: display_service.c
  group services\data_service
    ../../../framework/services/data_service/src/: data_service.c
  group services\ble_service
    ../../../framework/services/ble_service/src/: ble_service.c
  group services\battery_service
    ../../../framework/services/battery_service/src/: battery_service.c
  group application\ui_service
    ../application/ui_service/src/: ui_service.c
